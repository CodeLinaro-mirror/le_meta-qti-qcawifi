FILESEXTRAPATHS_append := "${THISDIR}:${THISDIR}/patches:"

SRC_URI += "file://0001-iw-Modify-frequency-to-channel-conversion-for-2G.patch \
"